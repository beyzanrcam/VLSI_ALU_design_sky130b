v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {INV/buffer.sym} 70 50 0 0 {name=x1 VSS=VSS VDD=VDD}
C {devices/ipin.sym} 30 50 0 0 {name=p3 lab=A}
C {devices/opin.sym} 110 50 0 0 {name=p4 lab=Y}
