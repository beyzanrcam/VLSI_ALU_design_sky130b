v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/ipin.sym} 70 -380 0 0 {name=p1 lab=A}
C {devices/ipin.sym} 70 -360 0 0 {name=p2 lab=!A}
C {devices/ipin.sym} 70 -340 0 0 {name=p3 lab=B}
C {devices/ipin.sym} 70 -320 0 0 {name=p4 lab=!B}
C {devices/lab_pin.sym} 160 -230 0 0 {name=p5 sig_type=std_logic lab=!A}
C {devices/lab_pin.sym} 160 -210 0 0 {name=p6 sig_type=std_logic lab=A}
C {devices/lab_pin.sym} 160 -190 0 0 {name=p7 sig_type=std_logic lab=B}
C {devices/lab_pin.sym} 160 -170 0 0 {name=p8 sig_type=std_logic lab=!B}
C {devices/lab_pin.sym} 160 -150 0 0 {name=p9 sig_type=std_logic lab=A}
C {devices/lab_pin.sym} 160 -130 0 0 {name=p10 sig_type=std_logic lab=!A}
C {devices/lab_pin.sym} 160 -110 0 0 {name=p11 sig_type=std_logic lab=B}
C {devices/lab_pin.sym} 160 -90 0 0 {name=p12 sig_type=std_logic lab=!B}
C {devices/opin.sym} 40 -300 0 0 {name=p13 lab=OUT
}
C {lab_pin.sym} 460 -160 0 1 {name=p14 sig_type=std_logic lab=OUT}
C {/foss/designs/HW3/cg4.sym} 310 -180 0 0 {name=x1}
