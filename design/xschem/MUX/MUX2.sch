v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {ipin.sym} 70 -320 0 0 {name=p1 lab=A}
C {ipin.sym} 70 -300 0 0 {name=p3 lab=B}
C {ipin.sym} 70 -260 0 0 {name=p4 lab=SEL}
C {opin.sym} 40 -240 0 0 {name=p13 lab=OUT
}
C {devices/lab_pin.sym} 450 -120 0 1 {name=p14 sig_type=std_logic lab=OUT}
C {devices/lab_pin.sym} 150 -130 0 0 {name=p2 sig_type=std_logic lab=A}
C {devices/lab_pin.sym} 150 -110 0 0 {name=p6 sig_type=std_logic lab=A}
C {ipin.sym} 70 -280 0 0 {name=p5 lab=!SEL}
C {devices/lab_pin.sym} 150 -50 0 0 {name=p7 sig_type=std_logic lab=!SEL}
C {devices/lab_pin.sym} 150 -150 0 0 {name=p8 sig_type=std_logic lab=SEL}
C {devices/lab_pin.sym} 150 -70 0 0 {name=p9 sig_type=std_logic lab=SEL}
C {devices/lab_pin.sym} 150 -190 0 0 {name=p10 sig_type=std_logic lab=!SEL}
C {devices/lab_pin.sym} 150 -170 0 0 {name=p11 sig_type=std_logic lab=B}
C {devices/lab_pin.sym} 150 -90 0 0 {name=p12 sig_type=std_logic lab=B}
C {../CG4/cg4.sym} 300 -140 0 0 {name=x1}
