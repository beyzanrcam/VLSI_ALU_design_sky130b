v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/ipin.sym} 70 -320 0 0 {name=p1 lab=A}
C {devices/ipin.sym} 70 -300 0 0 {name=p3 lab=B}
C {devices/ipin.sym} 190 -290 0 0 {name=p4 lab=SEL}
C {devices/opin.sym} 40 -240 0 0 {name=p13 lab=OUT
}
C {devices/lab_pin.sym} 450 -120 0 1 {name=p14 sig_type=std_logic lab=OUT}
C {devices/lab_pin.sym} 150 -170 0 0 {name=p2 sig_type=std_logic lab=A}
C {devices/lab_pin.sym} 150 -130 0 0 {name=p7 sig_type=std_logic lab=!SEL}
C {devices/lab_pin.sym} 150 -70 0 0 {name=p8 sig_type=std_logic lab=SEL}
C {devices/lab_pin.sym} 150 -150 0 0 {name=p9 sig_type=std_logic lab=SEL}
C {devices/lab_pin.sym} 150 -190 0 0 {name=p11 sig_type=std_logic lab=B}
C {devices/lab_pin.sym} 150 -50 0 0 {name=p12 sig_type=std_logic lab=B}
C {CG4/cg4.sym} 300 -140 0 0 {name=x1}
C {INV/inv.sym} 230 -290 0 0 {name=x2 VSS=VSS VDD=VDD}
C {devices/lab_pin.sym} 270 -290 2 0 {name=p5 sig_type=std_logic lab=!SEL}
C {devices/lab_pin.sym} 150 -110 0 0 {name=p15 sig_type=std_logic lab=!SEL}
C {devices/lab_pin.sym} 150 -90 0 0 {name=p16 sig_type=std_logic lab=A}
