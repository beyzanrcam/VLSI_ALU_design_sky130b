v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/ipin.sym} 60 -330 0 0 {name=p1 lab=A}
C {devices/ipin.sym} 60 -310 0 0 {name=p2 lab=!A}
C {devices/ipin.sym} 60 -290 0 0 {name=p3 lab=B}
C {devices/ipin.sym} 60 -270 0 0 {name=p4 lab=!B}
C {devices/lab_pin.sym} 150 -180 0 0 {name=p5 sig_type=std_logic lab=!A}
C {devices/lab_pin.sym} 150 -120 0 0 {name=p6 sig_type=std_logic lab=A}
C {devices/lab_pin.sym} 150 -160 0 0 {name=p7 sig_type=std_logic lab=B}
C {devices/lab_pin.sym} 150 -140 0 0 {name=p8 sig_type=std_logic lab=!B}
C {devices/lab_pin.sym} 150 -100 0 0 {name=p9 sig_type=std_logic lab=A}
C {devices/lab_pin.sym} 150 -80 0 0 {name=p10 sig_type=std_logic lab=!A}
C {devices/lab_pin.sym} 150 -40 0 0 {name=p11 sig_type=std_logic lab=B}
C {devices/lab_pin.sym} 150 -60 0 0 {name=p12 sig_type=std_logic lab=!B}
C {devices/opin.sym} 30 -250 0 0 {name=p13 lab=OUT
}
C {lab_pin.sym} 450 -110 0 1 {name=p14 sig_type=std_logic lab=OUT}
C {../CG4/cg4.sym} 300 -130 0 0 {name=x1}
