v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {INV/inv.sym} 130 0 0 0 {name=x1 VSS=VSS VDD=VDD}
C {NAND/nand2.sym} 30 0 0 0 {name=x2 VSS=VSS VDD=VDD}
C {devices/ipin.sym} -30 -20 0 0 {name=p1 lab=A}
C {devices/ipin.sym} -30 20 0 0 {name=p2 lab=B}
C {devices/opin.sym} 170 0 0 0 {name=p3 lab=Y}
