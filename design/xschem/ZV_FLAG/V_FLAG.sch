** sch_path: design/xschem/ZV_FLAG/V_FLAG.sch
**.subckt V_FLAG V C MSB1 MSB2
*.opin V
*.ipin C
*.ipin MSB1
*.ipin MSB2
x5 MSB1 MSB2 net1 XOR2
x6 C net1 V XOR2
**.ends
.end
