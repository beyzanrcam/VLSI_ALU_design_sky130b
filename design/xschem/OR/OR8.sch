v {xschem version=3.1.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {devices/opin.sym} 420 -30 0 0 {name=p7 lab=S6}
C {devices/opin.sym} 420 -10 0 0 {name=p8 lab=S7}
C {devices/opin.sym} 420 -90 0 0 {name=p4 lab=S3}
C {devices/opin.sym} 420 -70 0 0 {name=p5 lab=S4}
C {devices/opin.sym} 420 -50 0 0 {name=p6 lab=S5}
C {devices/opin.sym} 420 -150 0 0 {name=p1 lab=S0}
C {devices/opin.sym} 420 -130 0 0 {name=p2 lab=S1}
C {devices/opin.sym} 420 -110 0 0 {name=p3 lab=S2}
C {devices/ipin.sym} -180 30 0 0 {name=p12 lab=B1}
C {devices/ipin.sym} -180 50 0 0 {name=p14 lab=B2}
C {devices/ipin.sym} -180 70 0 0 {name=p16 lab=B3}
C {devices/ipin.sym} -180 90 0 0 {name=p18 lab=B4}
C {devices/ipin.sym} -180 110 0 0 {name=p20 lab=B5}
C {devices/ipin.sym} -180 130 0 0 {name=p22 lab=B6}
C {devices/ipin.sym} -180 150 0 0 {name=p24 lab=B7}
C {devices/ipin.sym} -180 10 0 0 {name=p10 lab=B0}
C {devices/ipin.sym} -180 -150 0 0 {name=p9 lab=A0}
C {devices/ipin.sym} -180 -130 0 0 {name=p11 lab=A1}
C {devices/ipin.sym} -180 -110 0 0 {name=p13 lab=A2}
C {devices/ipin.sym} -180 -90 0 0 {name=p15 lab=A3}
C {devices/ipin.sym} -180 -70 0 0 {name=p17 lab=A4}
C {devices/ipin.sym} -180 -50 0 0 {name=p19 lab=A5}
C {devices/ipin.sym} -180 -30 0 0 {name=p21 lab=A6}
C {devices/ipin.sym} -180 -10 0 0 {name=p23 lab=A7}
C {NOT/not8.sym} 270 -80 0 0 {name=x1 VSS=VSS VDD=VDD}
C {NOR/nor_8_bitwise.sym} -30 0 0 0 {name=x2 VSS=VSS VDD=VDD}
