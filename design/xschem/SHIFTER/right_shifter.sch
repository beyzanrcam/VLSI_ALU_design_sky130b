v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/ipin.sym} 100 80 3 1 {name=p5 lab=A7}
C {devices/opin.sym} 50 160 3 1 {name=p6 lab=S7}
C {devices/ipin.sym} 150 80 3 1 {name=p7 lab=A6}
C {devices/ipin.sym} 200 80 3 1 {name=p8 lab=A5}
C {devices/ipin.sym} 250 80 3 1 {name=p9 lab=A4}
C {devices/ipin.sym} 300 80 3 1 {name=p10 lab=A3}
C {devices/ipin.sym} 350 80 3 1 {name=p11 lab=A2}
C {devices/ipin.sym} 400 80 3 1 {name=p12 lab=A1}
C {devices/ipin.sym} 450 80 3 1 {name=p13 lab=A0}
C {devices/opin.sym} 100 160 3 1 {name=p14 lab=S6}
C {devices/opin.sym} 150 160 3 1 {name=p15 lab=S5}
C {devices/opin.sym} 200 160 3 1 {name=p16 lab=S4}
C {devices/opin.sym} 250 160 3 1 {name=p17 lab=S3}
C {devices/opin.sym} 300 160 3 1 {name=p18 lab=S2}
C {devices/opin.sym} 350 160 3 1 {name=p19 lab=S1}
C {devices/opin.sym} 450 160 3 1 {name=p20 lab=C}
C {INV/buffer.sym} 450 120 1 0 {name=x1 VSS=VSS VDD=VDD}
C {INV/buffer.sym} 400 120 1 0 {name=x2 VSS=VSS VDD=VDD}
C {INV/buffer.sym} 350 120 1 0 {name=x3 VSS=VSS VDD=VDD}
C {INV/buffer.sym} 300 120 1 0 {name=x4 VSS=VSS VDD=VDD}
C {INV/buffer.sym} 250 120 1 0 {name=x5 VSS=VSS VDD=VDD}
C {INV/buffer.sym} 200 120 1 0 {name=x6 VSS=VSS VDD=VDD}
C {INV/buffer.sym} 150 120 1 0 {name=x7 VSS=VSS VDD=VDD}
C {INV/buffer.sym} 100 120 1 0 {name=x8 VSS=VSS VDD=VDD}
C {devices/opin.sym} 400 160 1 0 {name=p21 lab=S0}
C {INV/inv.sym} 50 120 1 0 {name=x9 VSS=VSS VDD=VDD}
C {devices/vdd.sym} 50 80 0 0 {name=l1 lab=VDD}
